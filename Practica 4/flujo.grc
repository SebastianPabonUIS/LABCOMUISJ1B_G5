<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>FlujoPM</value></param>
<param><key>author</key><value>Edson Rey &amp; Sebastian Pabon</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FLUJOPM</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ac</value></param>
<param><key>value</key><value>60</value></param>
<param><key>label</key><value>Amplitud de la portadora</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Am</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>amplitud del mensaje</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e-6</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fm</value></param>
<param><key>value</key><value>1e3</value></param>
<param><key>label</key><value>frecuencia del mensaje</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e3</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>20e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>kp</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Constante Kp</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>Envolvente_Compleja_J1B_G5</key>
<param><key>id</key><value>Envolvente_Compleja_J1B_G5_0</value></param>
<param><key>Ac</key><value>Ac</value></param>
<param><key>kp</key><value>kp</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>Am</value></param>
<param><key>freq</key><value>fm</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>Envolvente_Compleja_J1B_G5_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Envolvente_Compleja_J1B_G5_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>Envolvente_Compleja_J1B_G5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
